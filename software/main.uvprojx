# Keil uVision project main.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: DS_CM3 ARM
  pack: Keil.V2M-MPS2_DSx_BSP.1.1.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main
  c flags: Optim=7 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 v6Lto=1 wLevel=3
  c include: .\Source\peripheral\include;.\Source\interface\include;.\Source\lib
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  group Source Group 1
    ./Source/peripheral/: dht20.cpp esp8266.cpp leds.cpp
    ./Source/interface/: gpio.cpp uart.cpp i2c.cpp
    ./Source/lib/: common.cpp
    ./Source/: main.cpp
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
